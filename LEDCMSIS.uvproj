# Keil uVision project LEDCMSIS.uvproj, settings and files
target LEDBlinky (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LEDCMSIS +hex
  c flags: Optim=1
  c include: ..\CMSIS\Drivers\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ../CMSIS/Core/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group System
    ../CMSIS/Core/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group Source
    ./: main.c
  group Library
    ../CMSIS/Drivers/source/: lpc17xx_gpio.c
